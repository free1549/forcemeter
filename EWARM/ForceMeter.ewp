# IAR project ForceMeter.ewp, settings and files
configuration ForceMeter (ARM, debug)
  General.OGChipSelectEditMenu: STM32F302CB ST STM32F302CB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F302xC
  ICCARM.CCIncludePath2: ../Inc; ../Src; ..\..\STM32Cube_FW_F3\Drivers\STM32F3xx_HAL_Driver\Inc; ..\..\STM32Cube_FW_F3\Drivers\STM32F3xx_HAL_Driver\Inc\Legacy; ..\..\STM32Cube_FW_F3\Drivers\CMSIS\Device\ST\STM32F3xx\Include; ..\..\STM32Cube_FW_F3\Drivers\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ForceMeter.hex
  ILINK.IlinkOutputFile: ForceMeter.out
  ILINK.IlinkIcfFile: stm32f302xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f302xc.s
  group Application/User
    ../Src/: ad717x.c main.c stm32f3xx_hal_msp.c stm32f3xx_it.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ../../STM32Cube_FW_F3/Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_spi.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c
